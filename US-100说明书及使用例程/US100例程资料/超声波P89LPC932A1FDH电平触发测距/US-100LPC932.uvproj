# Keil uVision project US-100LPC932.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LPC932 Philips
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM (0-0x1FF) CLOCK(12000000) MODP2
  output: US-100LPC932 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    D:/US-100_Project/P89LPC932A-Pro/US-100LPC932/: START900.A51
    ./: US100Test.c US100Test.h
