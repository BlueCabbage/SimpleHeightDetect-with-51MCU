# Keil uVision project ___电赛示高.uvproj, settings and files
target ___电赛示高 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: ___电赛示高 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Usr
    ../Usr/: main.c
